# Keil uVision project rt_tsic506.uvprojx, settings and files
target tsic506 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403VG ArteryTek
  pack: Keil.AT32F4xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt_tsic506 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403Zx_XL
  c include: ..\..\..\Libraries\drivers\inc;..\..\..\Libraries\startup\CoreSupport;..\..\..\Libraries\startup\DeviceSupport;..\..\..\Libraries\utilities\rtthread\components\net\canfestival\slave_od;..\..\..\Libraries\utilities\rtthread\components\net\canfestival\inc;..\..\..\Libraries\utilities\rtthread\components\utilities\ulog;..\..\..\Libraries\utilities\rtthread\components\finsh;..\..\..\Libraries\utilities\rtthread\components\drivers\include;..\..\..\Libraries\utilities\rtthread\components\drivers\include\drivers;..\..\..\Libraries\utilities\rtthread\components\utilities\utest;..\..\..\Libraries\utilities\rtthread\bsp\at32\inc;..\..\..\Libraries\utilities\rtthread\components\dfs\include;..\..\..\Libraries\utilities\rtthread\components\libc\compilers\common;..\..\..\Libraries\utilities\rtthread\components\libc\compilers\armlibc;..\..\..\Libraries\utilities\rtthread\components\dfs\filesystems\devfs;..\..\..\Libraries\utilities\rtthread\include;..\src\config;..\..\..\Libraries\devices\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group rt_kernel
    ../../../Libraries/utilities/rtthread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group rt_kernal/rtt_driver
    ../../../Libraries/utilities/rtthread/components/drivers/serial/: serial.c
    ../../../Libraries/utilities/rtthread/components/drivers/misc/: pin.c
  group user
    ../src/: main.c my_thread.c
  group at32_driver
    ../../../Libraries/drivers/src/: common.c gpio_init.c systemclk.c uart.c standby.c exti.c
  group startup
    ../../../Libraries/startup/DeviceSupport/startup/mdk/: startup_at32f403vx_xl.s
  group libc
    ../../../Libraries/utilities/rtthread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../Libraries/utilities/rtthread/components/libc/compilers/armlibc/: stdio.c
  group finsh
    ../../../Libraries/utilities/rtthread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group filesystem
    ../../../Libraries/utilities/rtthread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../Libraries/utilities/rtthread/components/dfs/filesystems/devfs/: devfs.c
  group cpu
    ../../../Libraries/utilities/rtthread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group rt_driver
    ../../../Libraries/utilities/rtthread/bsp/at32/src/: drv_usart.c drv_gpio.c
  group config
    ../src/config/: rtconfig.h
  group device
    ../../../Libraries/devices/src/: tsic506.c
