# Keil uVision project bl_test2.uvprojx, settings and files
target bl_test (ARM-ADS)
  device: AT32F403ZG ArteryTek
  pack: Keil.AT32F4xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bl_test2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: main.c
