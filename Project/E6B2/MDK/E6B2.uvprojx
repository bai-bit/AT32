# Keil uVision project E6B2.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403ZG ArteryTek
  pack: Keil.AT32F4xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: E6B2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403Zx_XL
  c include: ..\..\..\Libraries\drivers\inc;..\..\..\Libraries\startup\CoreSupport;..\..\..\Libraries\startup\DeviceSupport;..\..\..\Libraries\utilities\inc;..\..\..\Libraries\utilities\rtthread\include\libc;..\..\..\Libraries\utilities\rtthread\include;..\..\..\Libraries\utilities\rtthread\src;..\..\..\Libraries\utilities\rtthread\bsp\at32;..\src\src\config
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: main.c
    ../src/src/: my_thread.c
  group driver
    ../../../Libraries/drivers/src/: common.c gpio_init.c systemclk.c uart.c at32_timer.c
  group startup
    ../../../Libraries/startup/DeviceSupport/startup/mdk/: startup_at32f403zx_xl.s
  group utilities
    ../../../Libraries/utilities/src/: imu_data_decode.c packet.c
  group config
    ../src/src/config/: rtconfig.h
  group rtthread\kernel
    ../../../Libraries/utilities/rtthread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group rtthread\libcpu\arm\cortex-m4
    ../../../Libraries/utilities/rtthread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
